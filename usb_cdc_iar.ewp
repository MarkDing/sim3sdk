# IAR project usb_cdc_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SIM3U1XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: src; src\generated; C:\SiLabs\32bit\si32-1.1.0\si32Hal\sim3u1xx; C:\SiLabs\32bit\si32-1.1.0\si32Hal\SI32_Modules; C:\SiLabs\32bit\si32-1.1.0\si32Hal\CPU
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_cdc_iar.srec
  ILINK.IlinkOutputFile: usb_cdc_iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated
    src/generated/: gCLKCTRL.c gCpu.c gFLASHCTRL0.c gModes.c gPB.c gUART0.c gUSB0.c
  group LUFA/Class
    src/LUFA/Drivers/USB/Class/Device/: CDCClassDevice.c
  group LUFA/Core
    src/LUFA/Drivers/USB/Core/SIM3U/: Device_SIM3U.c Endpoint_SIM3U.c EndpointStream_SIM3U.c USBController_SIM3U.c USBInterrupt_SIM3U.c
    src/LUFA/Drivers/USB/Core/: DeviceStandardReq.c USBTask.c
  group SIM3U1XX
    ../../../../../../SiLabs/32bit/si32-1.1.0/si32Hal/sim3u1xx/: SI32_LDO_A_Type.c SI32_LOCK_A_Type.c SI32_PBCFG_A_Type.c SI32_PMU_A_Type.c SI32_RSTSRC_A_Type.c
  group SiM3xxxx
    ../../../../../../SiLabs/32bit/si32-1.1.0/si32Hal/SI32_Modules/: SI32_AES_A_Type.c SI32_CAPSENSE_A_Type.c SI32_CMP_A_Type.c SI32_CRC_A_Type.c SI32_EMIF_A_Type.c SI32_EMIFIF_A_Type.c SI32_EPCA_A_Type.c SI32_EPCACH_A_Type.c SI32_EXTOSC_A_Type.c SI32_EXTVREG_A_Type.c SI32_FLASHCTRL_A_Type.c SI32_I2C_A_Type.c SI32_I2S_A_Type.c SI32_IDAC_A_Type.c SI32_IVC_A_Type.c SI32_LPTIMER_A_Type.c SI32_PCA_A_Type.c SI32_PCACH_A_Type.c SI32_PLL_A_Type.c SI32_RTC_A_Type.c SI32_SARADC_A_Type.c SI32_SPI_A_Type.c SI32_SSG_A_Type.c SI32_TIMER_A_Type.c SI32_UART_A_Type.c SI32_USART_A_Type.c SI32_USB_A_Type.c SI32_VMON_A_Type.c SI32_VREF_A_Type.c SI32_VREG_A_Type.c SI32_WDTIMER_A_Type.c
    ../../../../../../SiLabs/32bit/si32-1.1.0/si32Hal/sim3u1xx/: startup_sim3u1xx_iar.s system_sim3u1xx.c
  group usb_cdc_iar
    src/: main.c
  group VirtualSerial
    src/VirtualSerial/: Descriptors.c VirtualSerial.c
